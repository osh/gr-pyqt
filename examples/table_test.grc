<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.7'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>table_test</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>randval2</value></param>
<param><key>value</key><value>np.random.randint(10)*table_id</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>randval1</value></param>
<param><key>value</key><value>np.random.randn()*table_id</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>d0</value></param>
<param><key>value</key><value>dict([("Id", int(table_id)), ("Col1", randval1), ("Col2",randval2), ("ColX", 0)])</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>blocks_message_strobe</key>
<param><key>id</key><value>blocks_message_strobe_0</value></param>
<param><key>msg</key><value>pmt.cons(pmt.to_pmt(d0), pmt.PMT_NIL)</value></param>
<param><key>period</key><value>100</value></param>
</block>
<block>
<key>tables_pyqt_table</key>
<param><key>id</key><value>tables_pyqt_table_0</value></param>
<param><key>row_id</key><value>"Id"</value></param>
<param><key>columns</key><value>["Id","Col1", "Col2"]</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>table_id</value></param>
<param><key>label</key><value>ID</value></param>
<param><key>value</key><value>50</value></param>
<param><key>start</key><value>0</value></param>
<param><key>stop</key><value>100</value></param>
<param><key>step</key><value>1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
</block>
<connection><source_block_id>blocks_message_strobe_0</source_block_id><sink_block_id>tables_pyqt_table_0</sink_block_id><source_key>strobe</source_key><sink_key>pdus</sink_key></connection>
</flow_graph>

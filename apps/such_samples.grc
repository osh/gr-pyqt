<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.9'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>such_samples</value></param>
<param><key>author</key><value>Tim O'Shea</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>"Such Samples, %s Wow!"%(filename)</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>d</value></param>
<param><key>value</key><value>10</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>0</value></param>
<param><key>step</key><value>1</value></param>
<param><key>stop</key><value>100</value></param>
</block>
<block>
<key>variable_pyqt_text_input</key>
<param><key>id</key><value>f2</value></param>
<param><key>value</key><value>lambda x: numpy.correlate(numpy.abs(x), numpy.abs(x), 'same')</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
<param><key>_enabled</key><value>False</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filename</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/usr/local/workspace/rel/pybombs/src/test.dat</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>pyqt_cpower_plot</key>
<param><key>id</key><value>pyqt_cpower_plot_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>l</key><value>Many Power</value></param>
</block>
<block>
<key>pyqt_cpsd_plot</key>
<param><key>id</key><value>pyqt_cpsd_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>l</key><value>Very Frequency</value></param>
</block>
<block>
<key>pyqt_ctime_plot</key>
<param><key>id</key><value>pyqt_ctime_plot_0</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>l</key><value>Much Time</value></param>
</block>
<block>
<key>pyqt_ctime_plot</key>
<param><key>id</key><value>pyqt_ctime_plot_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>l</key><value>Very Correlate</value></param>
</block>
<block>
<key>pyqt_file_message_souce</key>
<param><key>id</key><value>pyqt_file_message_souce_0</value></param>
<param><key>filetype</key><value>"complex64"</value></param>
<param><key>filename</key><value>filename</value></param>
</block>
<block>
<key>pyqt_pdu_lambda</key>
<param><key>id</key><value>pyqt_pdu_lambda_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fn</key><value>f2</value></param>
</block>
<block>
<key>pyqt_pdu_lambda</key>
<param><key>id</key><value>pyqt_pdu_lambda_0_0</value></param>
<param><key>_enabled</key><value>False</value></param>
<param><key>fn</key><value>lambda x: numpy.log(1e-3+numpy.abs(x[0::d]))</value></param>
</block>
<block>
<key>pyqt_pdu_lambda</key>
<param><key>id</key><value>pyqt_pdu_lambda_0_1</value></param>
<param><key>_enabled</key><value>0</value></param>
<param><key>fn</key><value>f2</value></param>
</block>
<block>
<key>pyqt_range_input</key>
<param><key>id</key><value>pyqt_range_input_0</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>msg_complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>msg_complex</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>msg_complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>file_range</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>pyqt_range_input_0</sink_block_id><source_key>file_range</source_key><sink_key>file_range</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>pyqt_cpower_plot_0</sink_block_id><source_key>pdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>pyqt_cpsd_plot_0</sink_block_id><source_key>pdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>pyqt_ctime_plot_0</sink_block_id><source_key>pdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>pyqt_pdu_lambda_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pyqt_pdu_lambda_0</source_block_id><sink_block_id>pyqt_ctime_plot_0_0</sink_block_id><source_key>pdus</source_key><sink_key>cpdus</sink_key></connection>
<connection><source_block_id>pyqt_range_input_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>range</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>pyqt_range_input_0</source_block_id><sink_block_id>pyqt_file_message_souce_0</sink_block_id><source_key>range</source_key><sink_key>range</sink_key></connection>
</flow_graph>

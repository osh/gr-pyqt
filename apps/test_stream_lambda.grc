<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.8'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>test_stream_lambda</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>category</key><value>Custom</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>32000</value></param>
</block>
<block>
<key>analog_fastnoise_source_x</key>
<param><key>id</key><value>analog_fastnoise_source_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>noise_type</key><value>analog.GR_GAUSSIAN</value></param>
<param><key>amp</key><value>1</value></param>
<param><key>seed</key><value>0</value></param>
<param><key>samples</key><value>8192</value></param>
</block>
<block>
<key>blocks_throttle</key>
<param><key>id</key><value>blocks_throttle_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>samples_per_second</key><value>samp_rate</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>1,1</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>size</key><value>1024</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>gui_hint</key><value>1,0</value></param>
<param><key>label1</key><value></value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label2</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label3</key><value></value></param>
<param><key>color3</key><value>"green"</value></param>
<param><key>label4</key><value></value></param>
<param><key>color4</key><value>"black"</value></param>
</block>
<block>
<key>pyqt_stream_lambda</key>
<param><key>id</key><value>pyqt_stream_lambda_0</value></param>
<param><key>fn</key><value>fn1</value></param>
<param><key>n_streams_in</key><value>2</value></param>
<param><key>n_streams_out</key><value>2</value></param>
<param><key>type_in</key><value>complex</value></param>
<param><key>type_out</key><value>complex</value></param>
</block>
<block>
<key>variable_pyqt_text_input</key>
<param><key>id</key><value>fn2</value></param>
<param><key>value</key><value>lambda input_items, output_index: (input_items[0][:] * numpy.conj(input_items[1][:]))</value></param>
<param><key>gui_hint</key><value>0,1</value></param>
</block>
<block>
<key>variable_pyqt_text_input</key>
<param><key>id</key><value>fn1</value></param>
<param><key>value</key><value>lambda input_items, output_index: (input_items[output_index][::2]**2)*[0.1,0.2][output_index] + [-1,1][output_index]</value></param>
<param><key>gui_hint</key><value>0,0</value></param>
</block>
<block>
<key>pyqt_stream_lambda</key>
<param><key>id</key><value>pyqt_stream_lambda_0_0</value></param>
<param><key>fn</key><value>fn2</value></param>
<param><key>n_streams_in</key><value>2</value></param>
<param><key>n_streams_out</key><value>1</value></param>
<param><key>type_in</key><value>complex</value></param>
<param><key>type_out</key><value>complex</value></param>
</block>
<connection><source_block_id>pyqt_stream_lambda_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>pyqt_stream_lambda_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>analog_fastnoise_source_x_0</source_block_id><sink_block_id>blocks_throttle_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>blocks_throttle_0</source_block_id><sink_block_id>pyqt_stream_lambda_0</sink_block_id><source_key>0</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pyqt_stream_lambda_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pyqt_stream_lambda_0</source_block_id><sink_block_id>pyqt_stream_lambda_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>pyqt_stream_lambda_0</source_block_id><sink_block_id>pyqt_stream_lambda_0_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>pyqt_stream_lambda_0_0</source_block_id><sink_block_id>qtgui_time_sink_x_0_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
</flow_graph>

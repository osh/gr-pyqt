<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.10'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>ss2</value></param>
<param><key>author</key><value>Tim O'Shea</value></param>
<param><key>category</key><value>Custom</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
<param><key>title</key><value>"Such Samples 2, %s Woww!!"%(filename)</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>center_freq_f</value></param>
<param><key>value</key><value>center_freq</value></param>
<param><key>gui_hint</key><value>0,1,1,1</value></param>
<param><key>label</key><value>Center Frequency</value></param>
<param><key>type</key><value>real</value></param>
</block>
<block>
<key>variable_qtgui_entry</key>
<param><key>id</key><value>samp_rate_f</value></param>
<param><key>value</key><value>samp_rate</value></param>
<param><key>gui_hint</key><value>0,0,1,1</value></param>
<param><key>label</key><value>Sample Rate</value></param>
<param><key>type</key><value>raw</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ymax</value></param>
<param><key>value</key><value>-40</value></param>
<param><key>gui_hint</key><value>1,1,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-160</value></param>
<param><key>step</key><value>5</value></param>
<param><key>stop</key><value>20</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>ymin</value></param>
<param><key>value</key><value>-100</value></param>
<param><key>gui_hint</key><value>1,0,1,1</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-160</value></param>
<param><key>step</key><value>5</value></param>
<param><key>stop</key><value>20</value></param>
<param><key>rangeType</key><value>int</value></param>
</block>
<block>
<key>blocks_message_debug</key>
<param><key>id</key><value>blocks_message_debug_0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>center_freq</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>0</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>filename</value></param>
<param><key>type</key><value>string</value></param>
<param><key>value</key><value>/tmp/such_samples.cfile</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy</value></param>
</block>
<block>
<key>pyqt_file_message_sink</key>
<param><key>id</key><value>pyqt_file_message_sink_0</value></param>
<param><key>filetype</key><value>"complex64"</value></param>
<param><key>filename</key><value>filename+".excerpt"</value></param>
<param><key>label</key><value>Save Segment</value></param>
</block>
<block>
<key>pyqt_file_message_souce</key>
<param><key>id</key><value>pyqt_file_message_souce_0</value></param>
<param><key>filetype</key><value>"complex64"</value></param>
<param><key>filename</key><value>filename</value></param>
</block>
<block>
<key>pyqt_open</key>
<param><key>id</key><value>pyqt_open_0</value></param>
<param><key>label</key><value>Open</value></param>
</block>
<block>
<key>pyqt_range_input</key>
<param><key>id</key><value>pyqt_range_input_0</value></param>
<param><key>gui_hint</key><value>0,2,1,2</value></param>
</block>
<block>
<key>pyqt_select_input</key>
<param><key>id</key><value>pyqt_select_input_1</value></param>
<param><key>gui_hint</key><value>1,2,1,1</value></param>
<param><key>opt</key><value>['c_int16', 'c_uint16', 'c_int32', 'c_uint32', 'complex64', 'float32', 'c_&lt;i2', 'c_&gt;i2', 'c_&lt;i4', 'c_&gt;i4']</value></param>
</block>
<block>
<key>pyqt_set_title</key>
<param><key>id</key><value>pyqt_set_title_0</value></param>
<param><key>prefix</key><value>Such Samples: </value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>bw</key><value>samp_rate_f</value></param>
<param><key>fc</key><value>center_freq_f</value></param>
<param><key>gui_hint</key><value>3,2,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>msg_complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
<param><key>ymax</key><value>ymax</value></param>
<param><key>ymin</key><value>ymin</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>autoscale</key><value>True</value></param>
<param><key>gui_hint</key><value>2,2,1,1</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>color1</key><value>"blue"</value></param>
<param><key>label1</key><value></value></param>
<param><key>color2</key><value>"red"</value></param>
<param><key>label2</key><value></value></param>
<param><key>nconnections</key><value>2</value></param>
<param><key>srate</key><value>samp_rate_f</value></param>
<param><key>type</key><value>msg_complex</value></param>
</block>
<block>
<key>qtgui_waterfall_sink_x</key>
<param><key>id</key><value>qtgui_waterfall_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate_f</value></param>
<param><key>fc</key><value>center_freq_f</value></param>
<param><key>gui_hint</key><value>2,0,2,2</value></param>
<param><key>int_max</key><value>ymax</value></param>
<param><key>int_min</key><value>ymin</value></param>
<param><key>legend</key><value>False</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>msg_complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>parameter</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>type</key><value>eng_float</value></param>
<param><key>value</key><value>2.4e6</value></param>
</block>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>pyqt_range_input_0</sink_block_id><source_key>file_range</source_key><sink_key>file_range</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>pyqt_file_message_sink_0</sink_block_id><source_key>pdus</source_key><sink_key>pdus</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pyqt_file_message_souce_0</source_block_id><sink_block_id>qtgui_waterfall_sink_x_0</sink_block_id><source_key>pdus</source_key><sink_key>in</sink_key></connection>
<connection><source_block_id>pyqt_open_0</source_block_id><sink_block_id>blocks_message_debug_0</sink_block_id><source_key>filename</source_key><sink_key>print</sink_key></connection>
<connection><source_block_id>pyqt_open_0</source_block_id><sink_block_id>pyqt_file_message_souce_0</sink_block_id><source_key>filename</source_key><sink_key>file_open</sink_key></connection>
<connection><source_block_id>pyqt_open_0</source_block_id><sink_block_id>pyqt_set_title_0</sink_block_id><source_key>filename</source_key><sink_key>name</sink_key></connection>
<connection><source_block_id>pyqt_range_input_0</source_block_id><sink_block_id>pyqt_file_message_souce_0</sink_block_id><source_key>range</source_key><sink_key>range</sink_key></connection>
<connection><source_block_id>pyqt_select_input_1</source_block_id><sink_block_id>pyqt_file_message_souce_0</sink_block_id><source_key>pdus</source_key><sink_key>file_type</sink_key></connection>
</flow_graph>
